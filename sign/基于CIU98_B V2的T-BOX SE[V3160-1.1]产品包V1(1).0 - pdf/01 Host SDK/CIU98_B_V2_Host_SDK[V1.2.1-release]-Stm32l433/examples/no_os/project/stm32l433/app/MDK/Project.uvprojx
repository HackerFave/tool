# Keil uVision project Project.uvprojx, settings and files
target STM32L433 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L33 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L433xx
  c misc: --C99
  c include: ..\..\..\..\demo\app;..\..\..\..\demo\app\addins;..\..\..\..\demo\app\addins\thirdparty;.\user;..\..\..\..\..\..\extern\stm32l433\Include;..\..\..\..\..\..\extern\stm32l433\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\extern\stm32l433\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\port\no_os\stm32l433;..\..\..\..\..\..\src\api;..\..\..\..\..\..\src\cmd;..\..\..\..\..\..\src\ial;..\..\..\..\..\..\src\proto;..\..\..\..\..\..\src\util;..\..\..\..\demo\app\addins\thirdparty;..\..\..\..\..\..\extern;..\..\..\..\demo\update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group startup
    ./: startup_stm32l433.s
  group user
    ./user/: main.c
  group extern/stm32
    ../../../../../../extern/stm32l433/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_it.c system_stm32l4xx.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c
  group example/no_os/demo/app
    ../../../../demo/app/: comm_test.c auth_test.c ctrl_test.c fs_test.c info_test.c crypto_test.c key_test.c pin_test.c
    ../../../../demo/update/: update_test.c update_image.c
  group port/stm32
    ../../../../../../port/no_os/stm32l433/: port_i2c.c port_spi.c port_util.c port_config.c
  group src/api
    ../../../../../../src/api/: comm.c ctrl.c auth.c key.c crypto.c pin.c fs.c update.c info.c v2x.c
  group src/cmd
    ../../../../../../src/cmd/: apdu.c tpdu.c
  group src/proto
    ../../../../../../src/proto/: proto_i2c.c proto_spi.c
  group src/util
    ../../../../../../src/util/: util.c
  group extern
    ../../../../../../extern/: sm3.c sm4.c
  group example/no_os/demo/addins
    ../../../../demo/app/addins/: soft_alg.c string2byte.c
  group example/no_os/demo/addins/thirdparty
    ../../../../demo/app/addins/thirdparty/: des.c sha256.c
software components: CMSIS:CORE 5.0.1
