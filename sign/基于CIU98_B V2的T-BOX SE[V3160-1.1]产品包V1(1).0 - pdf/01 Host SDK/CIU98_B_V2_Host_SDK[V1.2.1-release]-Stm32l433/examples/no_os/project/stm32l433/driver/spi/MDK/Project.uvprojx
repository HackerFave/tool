# Keil uVision project Project.uvprojx, settings and files
target STM32L433 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L33 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L433xx
  c misc: --C99
  c include: .\user;..\..\..\..\..\..\..\extern\stm32l433\Include;..\..\..\..\..\..\..\extern\stm32l433\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\port\no_os\stm32l433;..\..\..\..\..\..\..\src\api;..\..\..\..\..\..\..\src\cmd;..\..\..\..\..\..\..\src\ial;..\..\..\..\..\..\..\src\proto;..\..\..\..\..\..\..\src\util;..\..\..\..\..\..\..\extern\stm32l433\STM32L4xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group startup
    ./: startup_stm32l433.s
  group user
    ./user/: main.c
  group stm32l4xx_hal_driver
    ../../../../../../../extern/stm32l433/STM32L4xx_HAL_Driver/Src/: system_stm32l4xx.c stm32l4xx_it.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c
  group port
    ../../../../../../../port/no_os/stm32l433/: port_config.c port_spi.c port_util.c
  group src/api
    ../../../../../../../src/api/: comm.c
  group src/proto
    ../../../../../../../src/proto/: proto_spi.c
  group src/util
    ../../../../../../../src/util/: util.c
software components: CMSIS:CORE 5.0.1
